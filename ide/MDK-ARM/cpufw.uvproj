# Keil uVision project cpufw.uvproj, settings and files
target cpufw (ARM-ADS)
  device: STM32F405VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: cpufw
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_FS
  c misc: --c99 --gnu
  c include: ..\..\project;..\..\cmsis;..\..\std-periph\inc;..\..\usb-core\dev-driver;..\..\usb-core\otg-driver;..\..\usb-files;..\..\usb-files\msc-class;..\..\usb-files\msc-class\inc;..\..\hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group project
    ../../project/: app.c emfat.c emfat.h StorageMode.c StorageMode.h Interrupts.c Interrupts.h stm32f4xx_conf.h system_stm32f4xx.c startup_stm32f4xx.s
  group usb-files
    ../../usb-files/: usb_bsp.c usb_conf.h usbd_conf.h usbd_desc.c usbd_desc.h usbd_usr.c
    ../../usb-files/msc-class/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group usb-dev-core
    ../../usb-core/dev-driver/: usbd_req.h usbd_req.c usbd_ioreq.h usbd_def.h usbd_ioreq.c usbd_core.h usbd_core.c
  group usb-otg-core
    ../../usb-core/otg-driver/: usb_bsp.h usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.c usb_dcd_int.h usb_defines.h usb_regs.h
  group std-periph
    ../../std-periph/src/: stm32f4xx_pwr.c stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c
